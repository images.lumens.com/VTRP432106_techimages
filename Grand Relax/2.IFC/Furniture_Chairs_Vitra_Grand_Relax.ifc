Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-19T17:04:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 19 17:04:29 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{480E37FD-112B-412A-B804-FCA35823C5D9}\ifc * Database version: 5507 * Database creation date: Fri Jun 19 17:04:27 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 19 17:04:28 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 19 17:04:28 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Grand Relax - Aluminium Polished, Furniture_Chairs_Vitra_Grand_Relax:Grand Relax - Aluminium Polished:325721
In: Level 1
Type - Material: Leather standard chocolate 68, Leather umbra grey 61, Aluminium polished 03
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Chairs_Vitra_Grand_Relax; ConvergoRefNr: 0089-2006-0001-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Grand Relax by Antonio Citterio is a luxurious reclining lounge chair combining outstanding comfort with compact dimensions and a classic understated aesthetic.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Lounge chairs; Uniclass2015Reference: Pr_40_50_12_48; Version: 1; VersionDate: 15/06/2020
Type - Identity Data(Type) - Collection: Grand Relax; Cost: 0; Description: Grand Relax by Antonio Citterio is a luxurious reclining lounge chair combining outstanding comfort with compact dimensions and a classic understated aesthetic.; Designer: Antonio Citterio; Manufacturer: Vitra; Model: Grand Relax - Aluminium Polished; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/3001035/storage/master/download/Factsheet%20Grand%20Relax-EN.pdf; Type Name: Grand Relax - Aluminium Polished; URL: https://www.vitra.com/en-un/living/product/details/grand-relax
Type - Materials and Finishes(Type) - LoungeChairTertiaryMaterial: Aluminium polished 03
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Lounge Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Chairs_Vitra_Grand_Relax; Features: Seat heights: 415 mm (310 mm with applied load, measured in accordance with EN 1335-1) or 465 mm (360 mm with applied load, measured in accordance with EN 1335-1).; Finish: Seat/body: moulded polyurethane foam with plastic frame and integrated synchronised mechanism with locking device. Base: four-star swivel base in die-cast aluminium, polished or powder-coated fi nish. Seat cushion: chamber cushion fi lled with polyurethane foam lozenges and ball fibres. Back cushion and neck cushion: chamber cushion fi lled with polyurethane foam cubes and a mix of goose feathers and down.; Grade: n/a; Material: Metal, plastic , textile/leather; ModelNumber: n/a; ModelReference: 09188102; Name: Vitra_Grand_Relax; ReplacementCost: n/a; Shape: Sculptured; Size: 690x810x1010-1060 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 09188102; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - OttomanVisibility: yes
Dimensions - Area: 2.95328 m2; Volume: 0.719592 m3
Materials and Finishes - LoungeChairMainMaterial: Leather umbra grey 61; LoungeChairSecondaryMaterial: Leather standard chocolate 68
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Chairs_Vitra_Grand_Relax: Grand Relax - Aluminium Polished; Family and Type: Furniture_Chairs_Vitra_Grand_Relax: Grand Relax - Aluminium Polished; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Chairs_Vitra_Grand_Relax: Grand Relax - Aluminium Polished; Type Id: Furniture_Chairs_Vitra_Grand_Relax: Grand Relax - Aluminium Polished; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
